Commit message: Modified urdf

File: URDF_files/d405_cam_with_stand.urdf (robot description, URDF)
Before this commit: robot D405_camera_with_stand, 3 links, 2 joints
Joints:
- joint camera_joint: origin xyz=-0.25 0 -0.024 rpy=-0.7854 0 -1.5708 -> xyz=-0.25 0 -0.024 rpy=0.7854 0 1.5708
